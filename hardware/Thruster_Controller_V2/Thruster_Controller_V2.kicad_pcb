# Repository mark-belbin/motor-controller (continued)

## KiCad design PCBs/XDS100v2 Programmer/XDS100v2 Programmer.kicad_pcb (continued)

Board: 2 copper layers, 91.0 x 38.0 mm, 43 parts (0 on the bottom side), 43 nets.

Other parts of the board:
J2: Conn_02x05_Odd_Even; 2x05_Prog_Header

Their connections:
/3V3_MCU: J2.1; also elsewhere on the board
/GPIO28: J2.3; also elsewhere on the board
/GPIO29: J2.5; also elsewhere on the board
/TCK: J2.4; also elsewhere on the board
/TDI: J2.8; also elsewhere on the board
/TDO: J2.6; also elsewhere on the board
/TMS: J2.2; also elsewhere on the board
/TRST: J2.10; also elsewhere on the board
GND: J2.7, J2.9; also elsewhere on the board

## KiCad design PCBs/Power Sense PCB/Power Sense PCB.kicad_pcb

Parts:
C1, C2, C7, C10, C13, C14, C15, C16: 0.1uF; C_0805; Digikey 478-12799-1-ND
C3, C4, C5, C6, C8, C9, C11, C12: C_Small; C_0603
C17: 330uF; CP_Radial_D8.0mm_P3.50mm; Digikey 493-15427-ND
D1: RED; LED_0603; Digikey 160-1447-1-ND
H1, H2, H3, H4: MountingHole; MountingHole_3mm_Pad_Via
J1: Jack-DC; BARREL_JACK; Digikey CP-002A-ND
J2: PWR_INV; AMASS_XT60-M
J3: PWR_INPUT; AMASS_XT60-M
J4: PHASE_A_INV; 3mm_Bullet_RA
J5: PHASE_A_MOTOR; 3mm_Bullet_RA
J6: PHASE_B_INV; 3mm_Bullet_RA
J7: PHASE_B_MOTOR; 3mm_Bullet_RA
J8: PHASE_C_INV; 3mm_Bullet_RA
J9: PHASE_C_MOTOR; 3mm_Bullet_RA
J10: Test Conn; Pin_Header_Straight_1x09_Pitch2.54mm; Digikey 3M9457-09-ND
NT1, NT2, NT3, NT4, NT5, NT6, NT7, NT8: Net-Tie_2; NetTie-2_SMD_Pad0.25mm
R1, R2, R13, R17: 4.99k; R_0603; Digikey P4.99KDBCT-ND
R3, R4, R10, R14: 5m; R_2512_Sense; Digikey YAG6124CT-ND
R5, R6, R12, R15: R_Small_US; R_0603
R7, R16, R18, R19: 22k; R_0603; Digikey P22KDBCT-ND
R8, R9, R11: 10k; R_0603
R20: 330; R_0603; Digikey RHM330DCT-ND
TP1: V_BUS; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5117-ND
TP2, TP4, TP8, TP10, TP15, TP17, TP19, TP23: GND_REF; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5001-ND
TP3: V_PHASE_A; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5117-ND
TP5: I_BUS; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5119-ND
TP6: I_PHASE_A; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5119-ND
TP7: BUS; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5116-ND
TP9: V_PHASE_B; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5117-ND
TP11, TP12, TP13: NEUTRAL_REF; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5001-ND
TP14: I_PHASE_B; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5119-ND
TP16: V_PHASE_C; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5117-ND
TP18: I_PHASE_C; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5119-ND
TP20: PHASE_A; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5116-ND
TP21: PHASE_B; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5116-ND
TP22: PHASE_C; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Digikey 36-5116-ND
U1, U2, U3, U4: INA240A1D; SOIC-8_3.9x4.9mm_Pitch1.27mm; Digikey 296-49646-1-ND

Connections:
+5V: C7.1, C10.1, C13.1, C14.1, C17.1, D1.2, J1.1, U1.3 (REF2), U1.6 (V+), U2.3 (REF2), U2.6 (V+), U3.3 (REF2), U3.6 (V+), U4.3 (REF2), U4.6 (V+)
/I_BUS: C5.1, J10.2, R5.1, TP5.1
/I_PHASE_A: C6.1, J10.6, R6.1, TP6.1
/I_PHASE_B: C9.1, J10.7, R12.1, TP14.1
/I_PHASE_C: C12.1, J10.8, R15.1, TP18.1
/MOTOR_NEUTRAL: R8.1, R9.1, R11.1, TP11.1, TP12.1, TP13.1
/PHASE_A_MOTOR: J5.1, NT4.1, R4.1, R8.2, TP20.1
/PHASE_B_MOTOR: J7.1, NT6.1, R9.2, R10.1, TP21.1
/PHASE_C_MOTOR: J9.1, NT8.1, R11.2, R14.1, TP22.1
/V_BUS: C1.1, J10.1, R1.2, R19.2, TP1.1
/V_PHASE_A: C2.1, J10.3, R2.2, R7.2, TP3.1
/V_PHASE_B: C15.1, J10.4, R13.2, R16.2, TP9.1
/V_PHASE_C: C16.1, J10.5, R17.2, R18.2, TP16.1
GND: C1.2, C2.2, C5.2, C6.2, C7.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, J1.2, J1.3, J2.1, J3.1, J10.9, R1.1, R2.1, R13.1, R17.1, R20.2, TP2.1, TP4.1, TP8.1, TP10.1, TP15.1, TP17.1, TP19.1, TP23.1, U1.2 (GND), U1.4 (GND), U1.7 (REF1), U2.2 (GND), U2.4 (GND), U2.7 (REF1), U3.2 (GND), U3.4 (GND), U3.7 (REF1), U4.2 (GND), U4.4 (GND), U4.7 (REF1)
unnamed: C3.1, NT2.2, U1.8 (+)
unnamed: C3.2, NT1.2, U1.1 (-)
unnamed: C4.1, NT4.2, U2.8 (+)
unnamed: C4.2, NT3.2, U2.1 (-)
unnamed: C8.1, NT6.2, U3.8 (+)
unnamed: C8.2, NT5.2, U3.1 (-)
unnamed: C11.1, NT8.2, U4.8 (+)
unnamed: C11.2, NT7.2, U4.1 (-)
unnamed: D1.1, R20.1
unnamed: J2.2, NT1.1, R3.2, R19.1, TP7.1
unnamed: J3.2, NT2.1, R3.1
unnamed: J4.1, NT3.1, R4.2, R7.1
unnamed: J6.1, NT5.1, R10.2, R16.1
unnamed: J8.1, NT7.1, R14.2, R18.1
unnamed: R5.2, U1.5
unnamed: R6.2, U2.5
unnamed: R12.2, U3.5
unnamed: R15.2, U4.5

Notes on the sheet:
For RC LPFs, start with 1kHz corner freq, adjust later
See if 1000pF shunt cap helps for current sense inputs
"Fake" neutral star point
Should be approx the same voltage as the real motor neutral, since phases are close to balanced.
Current sense chips bypass cap
For data aquistion via Arduino or similar.
All signals 0-5V

Board: 2 copper layers, 73.5 x 85.0 mm, 87 parts (0 on the bottom side), 32 nets.

## Commit log (part)

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2020-01-06 Added Legacy Files
    - Added powertrain test PCB files
2020-01-14 Created Project
2020-01-14 Selected Footprints
    - Created and assigned all required footprints
2020-01-14 Netlist & PCB
    - Created netlist
    - Initial layout import
2020-01-15 Removed Pulldown
    - Removed pulldown on TRST line
    - Will be permanently added to the main test board or integrated board.
    - If programmer is not plugged in, the board will automatically boot to flash. If connected, the option is there to connect the TRST pin to JTAGTRST for JTAG debugging, while still enabling boot from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
2020-01-16 Updated TI_MCU Sheet
    -Added all required components onto the TI-MCU sheet other than the external connections (header pins on the dev board)
    - Added pulldown and pullup resistors for proper JTAG debug and flashing functionality.
2020-01-19 Removed Unused Pins
    - GPIO34 and TDO switch options are useless for this application, removed them to reduce complexity.
    - Updated programming pin interface
2020-01-19 CAN and Minor Changes
    - Added CAN Controller (MCP2515) and CAN transciever
    - Added net-ties to shunts
    - Removed all +12V references and replaced with +BATT references.
2020-01-20 Testpoints
    - Added Testpoints everywhere!
    - Schematic is "done" and any mistakes should be able to be corrected with small bodges later
2020-01-22 Assigned Footprints
    - All footprints assigned
    - Created RA 3mm bullet fooprint, may need to adjust it later
    - Fixed errors
2020-01-22 Small Tweaks
    - Removed double CAN int pullup
    - Double checked overall schematic
2020-01-23 Schematic + BOM
    - Added 0.1uF decoupling caps
    - Added resistor division, same as DRV8305 eval board
    - Spec'd more of the BOM
2020-01-24 Layout + Routing
    - Added 5V LED indicatior
    - Added 330uF bulk cap on 5V rail
    - Changed 8pin to 9pin header (added ground)
    - Completed all layout and routing!
2020-01-27 Layout + Routing
    - Completed initial layout and routing, board is defined mechanically.
2020-01-27 3D Models + Gerbers
    - Updated all 3D models
    - Generated Gerbers
2020-01-28 Schematic + Footprints + BOM
    - Completed schematic
    - Assigned footprints
    - Updated BOM
2020-01-28 PCB Design Complete
    - Updated silkscreen
    - Small layout/routing changes
2020-01-29 Initial Layout, 3D Models, 0402s
    - Changed C2, C4, C9, C16, C18 to 0402
    - Some intial layout
    - All 3D models added
2020-01-30 Initial Layout
    - Full initial layout complete, can probably shrink the board further as routing is complete
2020-01-30 Gerber Zips
    - Zipped gerber files, sent them to JLC
2020-02-06 Routing
    - Routed most of DRV and TI chips
    - FETs are done
    - Added board outline
    - Added power and ground planes
2020-02-07 Initial Routing Complete
    - Connected all nets, no DRC errors
    - Still need to investigate the CAN logic level and add in a termination resistor
2020-02-07 Silkscreen
    - Finished up silkscreen
    - Checked routing, looks good
2020-02-07 Gerber Zip
2020-02-10 Created Project
    - Created new project that can be independant but not really portable.
    - Need to have motorware installed in te correct C:\ti\ location in order for this to work.
    - workspace is set to the entire "Software" folder
2020-02-11 Removing Fluff pt.1
    - Removed all DRV8301 references and #IFDEF statements for the DRV8305. Assuming DRV8305 usage for this project.
    - Removed all FAST 1v6 fixes, unnessecary since current version is 1v7
2020-02-14 Removed old Gerbers
2020-02-14 changed name
2020-02-21 UART Function
    - Successfully tested the sendOverUART() function. It works as expected, converting and sending global IQ values over UART to be viewed in PUTTY.
    - Still need to implement a timestamp feature and interrupts (ex once every 1 ms)
    - Still need to implement CSV format (easy)
2020-02-24 Timestamps and CSV Format
    - Timer0 interrupt will NOT work as it overrides the mainISR interrupt. Need to look at doing timestamps instead.
    - Accessed timer2 counter register using "halHandle->timerHandle[2]->TIM"
    - Changed "sendOverUART" to "sendCSV"
    - Added timestamps to sendCSV
2020-02-24 Increased Data Sent
    - Sent data is now time, set RPM, and actual RPM!
    - Updated both CSV functions to do this.
2020-02-25 Changed DRV8305 CS
    - Updated GPIO19 from SPISTEA to General Purpose in hal.c
    - Also added in GPIO32 as General Purpose for later use in the MCP2515 SPI CS
    - Removed useless GPIO statments
    - Added High and Low set commands to GPIO19 in the DRV8305.c writeSPI and readSPI functions. Measured with a scope to verify that the CS was indeed being pulled low correctly when applied and incorre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
2020-03-18 Dev Work
    - Small changes, addition of global on/off for UART data logging
2020-03-21 Layout
    - Trying out different layout approaches
2020-03-25 3V3 Regulator
    - Added in new 3V3 switching regulator, should save $$$ from the old one and about 1W versus a standard LDO
2020-03-30 More Layout + Routing
    - Added 3V3 converter
    - Moved DRV passives to directly underneath DRV chip on top layer
    - Fit power indication LEDs!
    - Think there should be enough space for everything! Routing to the left of TI chip and CAN controller to the right
2020-03-31 Silk and Routing
    - Fixed 5V LED indicator
    - Small layout and routing cleanups
    - Cleaned up Silkscreen
    - Board is "finished" !!
2020-04-01 BOM Changes
    - Found cheaper alternatives for some components
    - Changed sizing of some components to reduce cost where possible
2020-04-05 Changed Cap Bank + Gerbers
    - Changed cap bank to 3 aluminum poly caps plus 3 ceramic caps
    - Fixed routing
    - Generated Gerbers
2020-04-05 Updated BOM
    - Generated new BOM that relfects best case capacitor scenerio
2020-04-06 New Gerbers
    - Fixed some small errors in silkscreen on the thruster controller
    - Moved the programming header further from the edge, should help mechanically
2020-05-04 Created New Project
    - Copied over V1 and renamed to V2
    - Started deletion of removed components
2020-05-05 More Schematic Updates
    - Added initial F280041C symbol, still need to annotate it a bit more
    - Created initial BOM estimate
    - Still need to complete pinmapping for the MCU
2020-05-07 Started Layout
    - Imported new netlist
    - Ripped up old tracks
    - Added new outline
2020-08-21 More Routing
    - Routed ISEN lines better
    - Need to figure out VSEN
2020-08-22 Initial Routing and Layout
    - Completed all routing, all connections made and zero DRC errors.
    - Some courtyard errors but they are irrelevant
2020-08-22 Voltage Feedback Passives
    - Changed voltage feedback passives so they aren't right next to the fets this time.
    - Should help with soldering, was difficult on V1.
2020-08-22 Schematic Work / BOM
    - Double checking pinout
    - Adding digikey PNs for all components, cannot do a mouser run for a small quantity (1-2 boards)
    - Generated BOM
2020-09-02 3D Model
    Generated 3D Model for V2 controller
2020-09-05 Odd changes
    - my baddd
2020-09-05 Added motorcontrol SDK labs
2020-09-05 Updated is05_motor_id.c
    - Removed reference to induction motors, pwmdac, and data logging to shorten code
    - Added reference to the test led on the board for proper blinky.
2020-09-09 Standalone Project
    - Starting transfering files to create a standalone project that can be modified via proper version control.
    - Got lab08 working, renamed lab08 project to TI_ESC_V2!
2020-09-09 Independent Project
    - Finally! All project files are now under one portable roof, and it compiles!
    - Tested on the actual board and it fully works. Wooho
2020-09-10 Started CAN updates
    - Need to fix CAN transciever, add 5V rail!
    - Also subbing in a new transciever that is a newer PN and is lower in cost.
2020-09-10 Fixed CMPSS
    - Fixed CMPSS issue! Need to use trip 7,8,9! No superflurous OC trips like in the TI thread either, at least so far.
    - Removed some unnessecary comments.
2020-09-10 CMPSS still giving issues lol
    - Okay so that didn't work
    - Commenting out setupFaults for now, as it just causes trouble.
    - Must be the CMPSS ......
2020-09-18 Layout Changes
    - Flipping 3V3 regulator to the bottom of the board for better thermal performance.
    - Likewise placing 5V regulator on the bottom. This will require mech changes.
    - Need to compress things to the right more
2020-09-20 Silk and touchups
    - Updated aluminum poly cap, adjusted courtyard
    - Fixed silkscreen
    - Added more power planes near LDOs
    - Cleaned up some routing, still need to have a gooood look before sending this off. But, its 99% ready to go!
2020-11-23 Updated Footprints
    - Moved over to the default KiCAD footprints, the rounded ones.
    - Updated all 3D models as well
    - Need to fix a bunch of DRC errors ;(
2020-11-23 V2.1
    - Fixed silk
    - Cleaned up routing
    - Exported Gerbers
2021-01-16 Fixed a woopsies
    - Change R7 from 0402 to 0603 for future board spins
2021-01-17 Got it
    - Had to reinstall motorcontrol SDK in the CSS resource explorer. Didn't recognize that it was already installed
2021-02-08 Updated Mech
    - Removed outdated mech items and added new soldiworks part
2021-02-09 Added CAN Examples
    - Added example projects for CAN
2021-02-10 Trying to Implement CAN into HAL
    - Added CAN GPIO setup in HAL_setupGPIOs
    - Added CAN handle in hal_obj
    - Initilized CAN handle in HAL_init in hal.c
    - Added HAL_setupCANB function, included CAN init and CAN set bitrate
2021-02-10 Updated HAL_setupCANB
    - Added in CAN_startModule(CANB_BASE);
    - This is in all the example code, starts CANB module operations
2021-02-10 Fixing Sending
    - Moved CAN object definitions to setupCANB function in hal.c. This way they occur before CAN_start like in the example code
    - Added in new ReadCANwithID function from updated can.c library
    - CAN works now, but it sends as fast as possible and forever with one CANsend() function call!
2021-02-10 Sending verified!!!
    - Tested can_ex1 and it works as expected, need to find the difference between that code and my main code to fix the issue!
    - It was the ACK bit!! Needed another CAN node in order to create the ACK bit. Only scoping the bus causes no ACK bit, therefore the controller keeps sending the message until it sees an ACK bit.
2021-02-10 Sending Functions Done
    - Completed sending functions as well the custom float implementation.
2021-02-11 Tested CAN, Updated Functions
    - Testing CAN
    - Added proper 'motor enable' flag lol
    - Changed fault.all to fault.bit, fault.all is 1 if there is any fault
    - Fixed voltage and torque sending commands, verified the math with the received values : )
2021-02-11 Flash Configuration
    - Fixing the flash config linking errors so I can actually program these boards lol.
    - Just had to update the includes in the project settings to be the same as the RAM config.
2021-02-11 ForceAngle Disabled
    - Disabled forceAngle
    - Set accel initial value to 500.
2021-02-13 Tuned T200
    - The motor ID is super buggy but I got some parameters that should work. Rs is a lot lower than before obviously, about 0.09 ohm.
    Inductance and flux is the same as previous recorded measurements
2021-02-14 Board Programming
    - Finished flashing all the boards.
    - Still getting that high pitch noise when motor is ON, especially at RPM=0. Hard to say what is causing this or if it can even be fixed.
2021-02-21 Changes from motorcontrol sdk 3.01.00
    - Adding in some changes from the recent motorcontrol sdk 3.01.00.
    - Hoping to see if this fixes some of the CMPSS issues.
    - No CMPSS issues so far on the bench, will need to test this in the tub.
    - This compiles and runs fine.
2021-02-22 Updated lab05
    - Changed Kp factor to what is set in main project, should help reduce errors
2021-10-12 Started ReadMe Structure
    First crack at the skeleton
2021-10-17 Reorganized Repo
    - Changed folder names
    - Added some images and reference docs
2021-10-22 More README Work
    - Added more content and photos.
    - Updated the README structure, should be better now.
2021-10-25 Updated README
    - Added more images
    - Added a lot of README content
2021-10-25 Another Readme
    - Added another image, this one of the controller during testing
