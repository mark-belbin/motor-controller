# Repository mark-belbin/motor-controller

File README.md:

# FOC Motor Controller
This project was a multi-year effort to develop a ground-up, brushless motor (BLDC) controller for use in underwater robotics. 

The final controller is designed for T200 or T100 thrusters from BlueRobotics, boasting sensorless FOC and a miniature form-factor that is built right into the thruster.

## Key Features
- Sensorless FOC / sinusoidal commutation
- Input voltage up to 14V
- 250W Continuous Power
- CAN Bus telemetry and control
- Built into the T200 thruster, water-cooled
- Low underwater acoustic noise
- Up to 10-20% better efficiency than standard ESCs
- Great low-RPM operation and control
- *Ludicrous* mode, able to overmodulate and reach higher RPMs

> FOC Thruster Controller V2 Top View

> FOC Thruster Controller V2 Bottom View

# Table of Contents
1. [Introduction](#Introduction)
1. [FOC Benefits](#FOC-Benefits)
   1. [Phase Currents](#Phase-Currents)
   1. [Operating Noise](#Operating-Noise)
   1. [Efficiency](#Efficiency)
   1. [Other Benefits](#Other-Benefits)
1. [Motor Controller PCB](#Motor-Controller-PCB)
1. [Controller Firmware](#Controller-Firmware)
1. [T200 Thruster Mount](#T200-Thruster-Mount)
1. [Repository Content](#Repository-Content)

# Introduction
Brushless motors, such as BLDC or PMSM motors, have no physical link between the stator and rotor like in a standard DC motor. Therefore, these motors must be commutated (spun properly) using an external controller. The key is knowing where the motor's rotor is relative to the stator, such that the magnetic field of the stator can be generated with accuracy in order to successfully push along the rotor and get the motor to spin. 

For most hobby BLDC controllers, commonly referred to as electronic speed controllers (ESCs), motor commutation is accomplished through sensorless trapezoidal 6-step control. This commutation method steps through 6 distinct stator magnetic field positions in order to keep the motor spinning, based only on the feedback of the back-EMF voltage of the three motor phases. With only 6 available control positions, this method of commutation lacks maximum possible efficiency, but it remains a simple, reliable, and cheap control method. 

This motor controller design implements Field-oriented control (FOC), also known as sinusoidal control or sine wave control. The FOC algorithm used is provided by Texas Instrument's InstaSPIN product line. This enables FOC using sensorless feedback, meaning no extra encoders or sensors are attached to the motor. The TI sensorless system measures only the 3 phase voltages and 3 phase currents of the motor in order to estimate the current rotor position with high accuracy. Also important is the intrinsic properties of the motor, such as the phase resistance, inductance, and the motor flux linkage. InstaSPIN requires a motor calibration procedure be run on each unique motor to automatically determine these intrinsic values, if not the FOC algorithm will not run.

This custom FOC controller design was evaluated by comparing against the BlueRobotics Basic ESC R3, a standard hobby-style ESC. Both will run the same BlueRobotics T200 thruster, which is the intended use-case of the custom developed controller. 

> BlueRobotics T200 Thruster and Basic ESC R3.

# FOC Benefits
FOC has numerous potential benefits compared to traditional trapezoidal control. The most striking are the increase in efficiency and reduction in motor noise. This is possible since FOC control applies the most optimal stator magnetic field to push the rotor forward, and as a result generates clean and noise-free sine-wave current wave forms.

## Phase Currents

A comparison of current waveforms is shown below. Both the custom FOC controller and the Blue Robotics Basic ESC R3 are controlling a submerged T200 thruster at 2000 RPM. The FOC phase currents are much cleaner and closer to sinewaves, while the Basic ESC waveforms are more choppy and trapezoidal.

> FOC phase currents vs the BR Basic ESC R3 at 2000 RPM.

## Operating Noise

A significant difference in operating noise is observed because of the current waveform difference. This is very noticeable underwater too, as the louder electrical sounds generated by the Basic ESC travel far. By comparison the custom FOC controller runs quiet, especially for low to mid-range speeds of 0-2000 RPM.

## Efficiency

An efficiency test was completed for both the custom and off-the-shelf controllers. A T200 was secured and submerged in a relatively large tub full of water. A separate waterproof, magnetic RPM sensor was attached to the shaft of the T200 to independently measure the RPM of the thruster. Measurements were taken of the input power of the motor controller under test for RPM settings in steps of 100 RPM.

> FOC Controller Testing

The FOC controller is more efficient across nearly the entire RPM range. The graph below is shows superiority up until about 2500 RPM, beyond which the FOC controller has the same or slightly worse performance. This is a limitation of FOC, where at a certain voltage the controller will switch to overmodulation control, where the controller will gradually transition to trapezoidal control as the RPM increases. To remain efficient at upper RPMs, a higher input voltage would need to be supplied.

> FOC Controller vs the BR Basic ESC R3.

Here's how the efficiency difference changes over the course of the RPM range: 

- From 0 to 600 RPM, the FOC controller consumes about 50% less power, a percent increase in efficiency of 100-150%
- From 600 to 1500 RPM, 20% less power is consumed, a percent increase in efficiency of 25-30%.
- From 1500 to 2000 RPM, 15% less power is consumed, a percent increase in efficiency of 15-20%.
- From 2000 to 2500 RPM, 5-10% less power is consumed, a percent increase in efficiency of 8-10%.
- Beyond 2500 RPM, the FOC controller consumes 0-5% more power than the Basic ESC.

The outperformance at lower RPMs is significant, since many underwater robotics applications operate in this range, such as Autonomous Underwater Vehicles (AUVs) or Autonomous Surface Vessels (ASVs). Battery life is critical for these types of vehicles, and the reduction in motor power from FOC control could have a big impact. 

## Other Benefits

A few other minor benefits were observed with the custom controller and FOC:

1. Great low speed control; The controller can operate at speeds down to a few RPM, where the Basic ESC cuts out under about 100 RPM.
2. Clean forward / reverse switching; During 0 RPM crossings, the FOC controller is much more stable, and can make these forward / reverse jumps with much quicker acceleration (about 25kRPM/s vs 14kRPM/s). This could improve position locking or increase accuracy for delicate maneuvers. 
3. *Ludicrous mode*; The FOC controller's overmodulation feature can push the thruster faster than the Basic ESC for the same input voltage, about 100 more RPM at 12V. Since thrust is proportional to the square of the RPM, this extra 100 RPM is a nice power boost.

# Motor Controller PCB
The motor controller PCB design was created using KiCAD. It's a 4 layer board, approximately in the shape of a xx diameter circle. The notches in the design allow it to be dropped in a mount for the T200 thruster. The PCB project is located in "hardware/Thruster_Controller_V2". An older version of the controller is found in "hardware/Thruster_Controller_V1", with the main difference being a different TI microcontroller.

> FOC Thruster Controller V2 Angled View

The board itself is dense, and probably could have benefitted from a 6 layer design instead. However, limiting the design to 4 layers keeps the prototype costs very cheap. In total, for an order of 10 PCBAs, the total cost for the boards were about $2 each thanks to JLCPCB, and the total component cost is about $36.50 per board. So in total, less than $40 CAD per PCBA for only a 10 order quantity, not bad! At scale, this can shrink further, but probably not less than $25 per board.

Some major components are:
- TMS320F280041C -> TI microcontroller with InstaSPIN.
- DRV8320S -> Motor driver from TI.
- SIZF906DT -> Dual-MOSFETs in a compact package
- ATA6561 -> CAN Transceiver

# Controller Firmware
The controller firmware is based on MotorControl SDK 3.01 from TI. This SDK enables sensorless FOC with select TI microcontrollers. The microcontrollers have a proprietary InstaSPIN sensorless algorithm embedded in the ROM, which restricts this system to compatible TI MCUs only. 

The code is modified from a MotorControl SDK example lab, with extra drivers written for CAN communication. There is also some modification to disable a built-in overcurrent feature using the CMPSS. For whatever reason the feature seems to be bugged. I haven't yet figured out a good solution to either fix it or replace the overcurrent protection. So take caution if using this project as a base for something else! 

The IDE used is TIs Code Composer Studio, a customized version of Eclipse. The most up-to-date project is found in "firmware/TI_ESC_V2". The project is completely separated from TIs MotorControl SDK libraries, so it should be portable and importable in to Code Composer Studio from any computer with/without MotorControl SDK installed.

# T200 Thruster Mount
The motor controller PCBA was designed to be integrated into the back of the T200. The PCBA is first placed in an aluminum mount. Then, the thruster phase wires are soldered to the PCB. These wires are exposed by hacking away the jacket of the thruster very delicately. A new 10-conductor cable is then soldered to the PCB, replacing the original thruster cable. The final assembly is then potted, and mounted to the back of the thruster using the existing two screw holes originally for the back nose-cone. With this integration, the controller is water-cooled by the the thruster itself as water is forced passed it. 

> Fresh-cut aluminum PCBA mounts

> Anodized mount + PCBA

An interesting aspect of the mount design is the inclusion of a sealing disk. This disk, plus an o-ring, seals a programming port on the controller. This allows for reprogramming of the TI microcontroller while still maintaining water resistance. In the future it might be nice to include a bootloader on the microcontroller, which would allow programming over CAN instead, eliminating the need for this extra sealing disk! 

> T200 + Controller Angled View

> T200 + Controller Top View

# AUV Integration

An immediate application of the FOC thruster controller was in my final-year engineering senior design project; an autonomous underwater vehicle (AUV). The AUV includes six thrusters in the design, and I built an FOC controller in each one. In the end, the project was a resounding success, and a very good test scenario for the custom controllers. The controllers were smooth, operating well at low speeds, which is all the AUV needed. The thrusters also operated very quietly, even when pushing the AUV to higher speeds for fun. 

> Capstone AUV Top View

>  Capstone AUV Bottom View

Check out the AUV in action here -> https://www.youtube.com/watch?v=-c5bOXZom5M

# Repository Content
The repository is organized into 3 categories; hardware, firmware, and docs. Included in the hardware folder is the latest FOC controller V2, as well as an older version V1, and many test boards built to test and evaluate the project along the way. The firmware folder includes the latest V2 firmware, as well as the V1 firmware and sample test projects that were provided by TI and were useful for debugging.

## KiCad design hardware/Thruster_Controller_V2/Thruster_Controller_V2.kicad_pcb

Board: 4 copper layers, 35.5 x 37.0 mm, 112 parts (29 on the bottom side), 79 nets.

Parts:
C1: 4.7uF; C_0603_1608Metric
C2: 0.047uF; C_0402_1005Metric
C3, C43: 1uF; C_0805_2012Metric
C4, C5, C20, C28, C44: 1uF; C_0603_1608Metric
C6, C7, C8, C9, C17, C23, C31, C33, C34, C38, C39, C40, C41, C42: 0.1uF; C_0402_1005Metric
C10, C13, C15: 220uF; CP_Elec_6.3x5.8
C11, C12, C14: 0.01uF; C_0402_1005Metric
C16, C18, C21, C27: 10uF; C_0603_1608Metric
C19, C22, C29, C30, C32: 2.2uF; C_0402_1005Metric
C24, C25, C26: 2200pF; C_0402_1005Metric
C35: 10nF; C_0402_1005Metric
C36, C37: 9pF; C_0402_1005Metric
D1: BLUE; LED_0603_1608Metric
D2: RED; LED_0603_1608Metric
D3, D4: GREEN; LED_0603_1608Metric
D5: Orange; LED_0603_1608Metric
J1: PHASE_A; Phase_Pad
J2: PHASE_B; Phase_Pad
J3: PHASE_C; Phase_Pad
J4: CANL; CAN_Pad
J5: Pogo Conn; Tag-Connect_TC2050-IDC-NL
J6: CANH; CAN_Pad
J7: VIN; Bus_Pad
J8: GND; Bus_Pad
L1: 220 Ohm; L_0402_1005Metric
L3: 60 Ohm; L_0402_1005Metric
NT1, NT2, NT3, NT4, NT5, NT6: Net-Tie_2; NetTie-2_SMD_5mil
Q1, Q2, Q3: SIZF906DT
R1, R27, R30: 2.2k; R_0402_1005Metric
R2, R17, R18: 27.4k; R_0402_1005Metric
R3, R4, R5, R15: 22.0k; R_0402_1005Metric
R6, R25, R26, R28, R29: 10k; R_0402_1005Metric
R7: 2.7k; R_0603_1608Metric
R8, R9, R11: 5m; R_2512_6332Metric
R10: 330; R_0603_1608Metric
R12, R13, R14, R16: 4.99k; R_0402_1005Metric
R19: 100; R_0603_1608Metric
R20, R21, R22, R33: 56; R_0402_1005Metric
R23, R24, R32: 2.49k; R_0402_1005Metric
R31: 680; R_0603_1608Metric
R34: 220; R_0603_1608Metric
R35: 120; R_0402_1005Metric
TP1, TP2, TP3: TestPoint; TestPoint_Pad_D1.0mm
U1: NCP718AMT330; DFN-6-1EP_2x2mm_P0.65mm_EP1x1.6mm
U2: TMS320F280041C; QFN-56-1EP_7x7mm_P0.4mm_EP5.6x5.6mm
U3: DRV8320S; WQFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm
U4: NCP718AMT500; DFN-6-1EP_2x2mm_P0.65mm_EP1x1.6mm
U8: ATA6561; DFN-8-1EP_3x3mm_P0.65mm_EP1.7x2.05mm
Y1: 20 MHz; Crystal_SMD_SeikoEpson_FA238-4pin_3.2x2.5mm

Connections:
+3.3VA: C27.1, C34.1, C39.1, C40.1, C42.1, L1.2, U2.25, U2.40, U2.48, U2.54
+3V3: C4.1, C19.1, C21.1, D2.2, D3.2, D5.2, J5.1, L1.1, L3.1, R1.1, R6.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, TP1.1, U1.1, U8.5
+5V: C23.1, C28.1, C44.1, D4.2, TP2.1, U4.1, U8.3
+BATT: C1.1, C3.1, C5.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C43.1, D1.2, J7.1, Q1.4, Q2.4, Q3.4, R15.1, TP3.1, U1.4, U1.6, U3.3, U3.4, U4.4, U4.6
/CANH: J6.1, R35.2, U8.7
/CANL: J4.1, R35.1, U8.6
/Powertrain/DAC: R2.2, R17.2, R18.2, U2.13
/Powertrain/EN_GATE: U2.42, U3.22
/Powertrain/GH_A: Q2.1, U3.5
/Powertrain/GH_B: Q1.1, U3.12
/Powertrain/GH_C: Q3.1, U3.13
/Powertrain/GL_A: Q2.3, U3.7
/Powertrain/GL_B: Q1.3, U3.10
/Powertrain/GL_C: Q3.3, U3.15
/Powertrain/INH_A: U2.47, U3.25
/Powertrain/INH_B: U2.45, U3.27
/Powertrain/INH_C: U2.43, U3.29
/Powertrain/INL_A: U2.46, U3.26
/Powertrain/INL_B: U2.44, U3.28
/Powertrain/INL_C: U2.55, U3.30
/Powertrain/ISEN_A: R2.1, R23.2, U2.10
/Powertrain/ISEN_B: R17.1, R24.2, U2.16
/Powertrain/ISEN_C: R18.1, R32.2, U2.11
/Powertrain/PGA_GND: C24.2, C25.2, C26.2, R33.2, U2.9, U2.18
/Powertrain/Phase_A: J1.1, Q2.5, R4.1
/Powertrain/Phase_B: J2.1, Q1.5, R3.1
/Powertrain/Phase_C: J3.1, Q3.5, R5.1
/Powertrain/SH_A: Q2.2, U3.6
/Powertrain/SH_B: Q1.2, U3.11
/Powertrain/SH_C: Q3.2, U3.14
/Powertrain/SL_A: C14.2, NT5.2, Q2.6, R9.1, U3.8
/Powertrain/SL_B: C12.2, NT4.2, Q1.6, R8.1, U3.9
/Powertrain/SL_C: C11.2, NT6.2, Q3.6, R11.1, U3.16
/Powertrain/SNA: NT1.1, NT2.1, NT3.1, R33.1
/Powertrain/SPA: NT5.1, R20.1
/Powertrain/SPB: NT4.1, R21.1
/Powertrain/SPC: NT6.1, R22.1
/Powertrain/SPI_CLK: U2.56, U3.20
/Powertrain/SPI_CS: U2.28, U3.21
/Powertrain/SPI_MISO: R1.2, U2.31, U3.18
/Powertrain/SPI_MOSI: U2.30, U3.19
/Powertrain/VSEN_A: C7.1, R4.2, R13.1, U2.8
/Powertrain/VSEN_B: C6.1, R3.2, R12.1, U2.7
/Powertrain/VSEN_C: C8.1, R5.2, R14.1, U2.17
/Powertrain/VSEN_PVDD: C17.1, R15.2, R16.1, U2.6
/Powertrain/nFAULT: R6.2, R10.2, U2.52, U3.17
/RXCAN: U2.26, U8.4
/SCI_RX: J5.5, U2.3
/SCI_TX: J5.3, U2.2
/TCK: J5.4, U2.33
/TDI: J5.8, R25.2, U2.36
/TDO: J5.6, R26.2, U2.34
/TI_MCU/GPIO6: R31.2, U2.1
/TI_MCU/GPIO24: R29.2, U2.32
/TI_MCU/GPIO32: R28.2, U2.37
/TI_MCU/X1: C36.1, U2.39, Y1.1
/TI_MCU/X2: C37.1, U2.38, Y1.3
/TI_MCU/~RESET~: C35.1, R30.2, U2.4
/TMS: J5.2, R27.2, U2.35
/TXCAN: U2.27, U8.1
GND: C1.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, J5.7, J5.9, J8.1, NT1.2, NT2.2, NT3.2, R7.2, R8.2, R9.2, R11.2, R12.2, R13.2, R14.2, R16.2, R19.2, R34.2, U1.2, U1.3, U1.5, U1.7, U2.15, U2.19, U2.50, U2.57, U3.23, U3.31, U3.33, U4.2, U4.3, U4.5, U4.7, U8.2, U8.8, U8.9, Y1.2
unnamed: C2.1, U3.32
unnamed: C2.2, U3.1
unnamed: C5.2, U3.2
unnamed: C16.1, C41.1, U2.41
unnamed: C18.1, C33.1, U2.5
unnamed: C20.1, U3.24
unnamed: C22.1, C29.1, L3.2, U2.20
unnamed: C24.1, R20.2, R23.1
unnamed: C25.1, R21.2, R24.1
unnamed: C26.1, R22.2, R32.1
unnamed: C30.1, C32.1, U2.14
unnamed: C31.1, U2.24
unnamed: C38.1, U2.53
unnamed: D1.1, R7.1
unnamed: D2.1, R10.1
unnamed: D3.1, R19.1
unnamed: D4.1, R34.1
unnamed: D5.1, R31.1

File hardware/Thruster_Controller_V2/Thruster_Controller_V2_bom_V2.1.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet,Digikey,Voltage,Mouser
1,"Unpolarized capacitor, small symbol",C_Small,C11 C12 C14 C35,0.01uF,C_0402_1005Metric,4,,732-7545-1-ND,,
2,"Unpolarized capacitor, small symbol",C_Small,C2,0.047uF,C_0402_1005Metric,1,,490-10702-1-ND,,
3,"Unpolarized capacitor, small symbol",C_Small,C6 C7 C8 C9 C17 C23 C31 C33 C34 C38 C39 C40 C41 C42,0.1uF,C_0402_1005Metric,14,,490-10698-1-ND,,
4,"Unpolarized capacitor, small symbol",C_Small,C16 C18 C21 C27,10uF,C_0603_1608Metric,4,~,1276-1119-1-ND,,
5,"Unpolarized capacitor, small symbol",C_Small,C4 C5 C20 C28 C44,1uF,C_0603_1608Metric,5,,1276-1102-1-ND,,
6,"Unpolarized capacitor, small symbol",C_Small,C3 C43,1uF,C_0805_2012Metric,2,,1276-6470-1-ND,50V,
7,"Unpolarized capacitor, small symbol",C_Small,C19 C22 C29 C30 C32,2.2uF,C_0402_1005Metric,5,~,490-10451-1-ND,,
8,"Unpolarized capacitor, small symbol",C_Small,C24 C25 C26,2200pF,C_0402_1005Metric,3,,490-6359-1-ND,,
9,Unpolarized capacitor,C,C10 C13 C15,220uF,CP_Elec_6.3x5.8,3,~,565-APXJ160ARA221MF61GCT-ND,,
10,"Unpolarized capacitor, small symbol",C_Small,C1,4.7uF,C_0603_1608Metric,1,,1276-1900-1-ND,,
11,"Unpolarized capacitor, small symbol",C_Small,C36 C37,9pF,C_0402_1005Metric,2,~,490-5880-1-ND,,
12,"Light emitting diode, filled shape",LED_ALT,D1,BLUE,LED_0603_1608Metric,1,~,732-4966-1-ND,,
13,"Light emitting diode, filled shape",LED_ALT,D3 D4,GREEN,LED_0603_1608Metric,2,~,732-4980-1-ND,,
14,"Light emitting diode, filled shape",LED_ALT,D5,Orange,LED_0603_1608Metric,1,~,160-1180-1-ND,,
15,"Light emitting diode, filled shape",LED_ALT,D2,RED,LED_0603_1608Metric,1,~,732-4978-1-ND,,
16,"Generic connector, single row, 01x01, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x01,J4 J6,Conn_01x01,CAN_Pad,2,~,,,
17,"Generic connector, single row, 01x01, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x01,J7 J8,Conn_01x01,Bus_Pad,2,~,,,
18,"Generic connector, single row, 01x01, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x01,J1 J2 J3,PHASE_A,Phase_Pad,3,~,,,
19,"Generic connector, double row, 02x05, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_02x05_Odd_Even,J5,Pogo Conn,Tag-Connect_TC2050-IDC-NL,1,~,,,
20,"Inductor, small symbol",L_Small,L1,220 Ohm,L_0402_1005Metric,1,~,490-11021-1-ND,,
21,"Inductor, small symbol",L_Small,L3,60 Ohm,L_0402_1005Metric,1,~,445-172882-1-ND,,
22,"Net tie, 2 pins",Net-Tie_2,NT1 NT2 NT3 NT4 NT5 NT6,Net-Tie_2,NetTie-2_SMD_5mil,6,~,,,
23,,SIZF906DT,Q1 Q2 Q3,SIZF906DT,SIZF906DT,3,http://www.vishay.com/docs/67547/sizf906dt.pdf,SIZF906DT-T1-GE3CT-ND,,
24,"Resistor, US symbol",R_US,R19,100,R_0603_1608Metric,1,~,2019-RK73B1JTTD101JCT-ND,,
25,"Resistor, US symbol",R_US,R6 R25 R26 R28 R29,10k,R_0402_1005Metric,5,~,2019-RK73B1ETTP103JCT-ND,,
26,"Resistor, small US symbol",R_Small_US,R35,120,R_0402_1005Metric,1,~,311-120JRCT-ND,,
27,"Resistor, small US symbol",R_Small_US,R1 R27 R30,2.2k,R_0402_1005Metric,3,~,311-2.2KJRCT-ND,,
28,"Resistor, US symbol",R_US,R23 R24 R32,2.49k,R_0402_1005Metric,3,~,RMCF0402FT2K49CT-ND,,
29,"Resistor, US symbol",R_US,R7,2.7k,R_0603_1608Metric,1,~,RMCF0603JT2K70CT-ND,,
30,"Resistor, US symbol",R_US,R3 R4 R5 R15,22.0k,R_0402_1005Metric,4,~,RMCF0402FT22K0CT-ND,,
31,"Resistor, US symbol",R_US,R34,220,R_0603_1608Metric,1,~,2019-RK73B1JTTD221JCT-ND,,
32,"Resistor, US symbol",R_US,R2 R17 R18,27.4k,R_0402_1005Metric,3,~,RMCF0402FT27K4CT-ND,,
33,"Resistor, US symbol",R_US,R10,330,R_0603_1608Metric,1,~,RMCF0603JT330RCT-ND,,
34,"Resistor, US symbol",R_US,R12 R13 R14 R16,4.99k,R_0402_1005Metric,4,~,311-4.99KLRCT-ND,,
35,"Resistor, US symbol",R_US,R20 R21 R22 R33,56,R_0402_1005Metric,4,~,311-56JRCT-ND,,
36,"Resistor, US symbol",R_US,R8 R9 R11,5m,R_2512_6332Metric,3,,YAG6105CT-ND,,
37,"Resistor, US symbol",R_US,R31,680,R_0603_1608Metric,1,~,RMCF0603JT680RCT-ND,,
38,"High-Speed CAN Transceiver, 1Mbps, 5V supply, Vio pin, -40C to +125C, DFN-8",MCP2562-E-MF,U8,ATA6561,DFN-8-1EP_3x3mm_P0.65mm_EP1.7x2.05mm,1,https://ww1.microchip.com/downloads/en/DeviceDoc/20005991B.pdf,ATA6561-GBQW-NCT-ND,,579-ATA6561-GBQW-N
39,,DRV8320S,U3,DRV8320S,WQFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm,1,http://www.ti.com/lit/ds/symlink/drv8323r.pdf?HQS=TI-null-nu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,296-50725-1-ND,,595-DRV8320SRTVR
40,,NCP718AMT330,U1,NCP718AMT330,DFN-6-1EP_2x2mm_P0.65mm_EP1x1.6mm,1,https://www.mouser.ca/datasheet/2/308/NCP718-D-1224359.pdf,NCP718AMT330TBGOSCT-ND,,863-NCP718AMT330TBG
41,,NCP718AMT330,U4,NCP718AMT500,DFN-6-1EP_2x2mm_P0.65mm_EP1x1.6mm,1,https://www.onsemi.com/pub/Collateral/NCP718-D.PDF,‎NCP718AMT500TBGOSCT-ND‎,,863-NCP718BMT500TBG
42,,TMS320F280041C,U2,TMS320F280041C,QFN-56-1EP_7x7mm_P0.4mm_EP5.6x5.6mm,1,http://www.ti.com/lit/ds/symlink/tms320f280041.pdf?ts=158843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,296-F280041CRSHSRCT-ND,,595-F280041CRSHSR
43,"Three pin crystal, GND on pin 2",Crystal_GND2,Y1,20 MHz,Crystal_SMD_SeikoEpson_FA238-4pin_3.2x2.5mm,1,~,SER3629CT-ND,,

Component Groups:,43
Component Count:,109
Fitted Components:,109
Number of PCBs:,1
Total components:,109
Schematic Version:,V2.1
Schematic Date:,2020-09-04
PCB Variant:,[u'default']
BoM Date:,2021-05-12 3:15:47 PM
Schematic Source:,D:\FOC_Motor_Controller\motor-controller\PCBs\Thruster_Controller_V2\Thruster_Controller_V2.sch
KiCad Version:,Eeschema (5.1.9)-1

## KiCad design PCBs/Thruster_Controller/Thruster_Controller.kicad_pcb

Board: 4 copper layers, 36.0 x 37.5 mm, 110 parts (56 on the bottom side), 86 nets.

Parts:
C1: 4.7uF; C_0603
C2, C4: 0.047uF; C_0402
C3, C5, C20, C27, C28, C29, C39, C40, C41: 1uF; C_0603
C6, C7, C8, C17, C23, C30, C42: 0.1uF; C_0402
C9, C16, C18: 1000pF; C_0402
C10, C13, C15: 22uF; CP_Elec_6.3x5.8
C12, C14, C31: 22uF; C_1206
C19: 2.2uF; C_0603
C21, C22: 15pF; C_0402
C24, C25, C26: 2200pF; C_0402
C34, C35, C36, C37, C38: 2.2uF; C_0402
C49: 10uF; C_0805
C50: 22uF; C_0805
D1: BLUE; LED_0603
D2, D4: RED; LED_0603
D3: GREEN; LED_0603
D5: Orange; LED_0603
H1, H2: MountingHole; MountingHole_M2
J1: PHASE_A; Phase_Pad
J2: PHASE_B; Phase_Pad
J3: PHASE_C; Phase_Pad
J4, J6: Conn_01x01; CAN_Pad
J5: Pogo Conn; Tag-Connect_TC2050-IDC-NL
J7, J8: Conn_01x01; Bus_Pad
L1: 2.2uH; L_0805
L2: FB; L_0805
L3: FB; L_0402
NT1, NT2, NT3, NT4, NT5, NT6: Net-Tie_2; NetTie-2_SMD_5mil
Q1, Q2, Q3: SIZF906DT
R1, R6: 10k; R_0603
R2: 100; R_0603
R3, R4, R5, R15: 22.0k; R_0402
R7: 2.7k; R_0603
R8, R9, R11: 5m; R_2512
R10, R19: 330; R_0805
R12, R13, R14, R16: 4.99k; R_0402
R17, R18: 10k; R_0402
R20, R21, R22: 56; R_0402
R23: 100k; R_0402_NoSilk
R24, R31: 680; R_0603
R25, R26: 820; R_0402
R27, R28, R29, R30: 2.2k; R_0402
R35: 120; R_0402
TP1, TP2, TP3: TestPoint; TestPoint_Pad_D1.0mm
U1: DRV8305
U2: RTQ2569-50GQW; DFN-8-1EP_3x3mm_Pitch0.65mm
U3: MCP2515; QFN-20-1EP_4x4mm_Pitch0.5mm
U4: TPS62172DSGR; 8-Pin_WSON
U5: TMS320F28027F; LQFP-48_7x7mm_Pitch0.5mm
U8: MCP2562; DFN-8-1EP_3x3mm_Pitch0.65mm
Y1: 20MHz; Crystal_SMD_SeikoEpson_TSX3225-4pin_3.2x2.5mm

Connections:
+3V3: C23.1, C27.1, C28.1, C35.1, C42.1, C50.1, D2.2, D3.2, D5.2, J5.1, L1.2, L2.1, L3.1, R1.1, R6.1, R17.1, R18.1, R23.1, R25.1, R26.1, R30.1, TP1.1, U1.48, U3.18, U4.6, U8.5
+5V: C29.1, C30.1, C40.1, C41.1, D4.2, TP2.1, U2.6, U8.3
+BATT: C1.1, C10.1, C12.1, C13.1, C14.1, C15.1, C19.1, C31.1, C39.1, C49.1, D1.2, J7.1, Q1.4, Q2.4, Q3.4, R2.1, R15.1, TP3.1, U1.41, U2.1, U2.8, U4.2, U4.3
/CANH: J6.1, R35.2, U8.7
/CANL: J4.1, R35.1, U8.6
/GPIO28: J5.3, R6.2, R10.2, U1.8, U5.48
/GPIO29: J5.5, U5.1
/Powertrain/EN_GATE: U1.1, U5.41
/Powertrain/GH_A: Q3.1, U1.36
/Powertrain/GH_B: Q1.1, U1.29
/Powertrain/GH_C: Q2.1, U1.28
/Powertrain/GL_A: Q3.3, U1.33
/Powertrain/GL_B: Q1.3, U1.32
/Powertrain/GL_C: Q2.3, U1.25
/Powertrain/ISEN_A_DRV: R20.1, U1.16
/Powertrain/ISEN_B_DRV: R21.1, U1.17
/Powertrain/ISEN_C_DRV: R22.1, U1.18
/Powertrain/PWRGD: R1.2, R30.2, U1.13, U5.3
/Powertrain/Phase_A: J1.1, Q3.5, R5.1
/Powertrain/Phase_B: J2.1, Q1.5, R3.1
/Powertrain/Phase_C: J3.1, Q2.5, R4.1
/Powertrain/SH_A: Q3.2, U1.35
/Powertrain/SH_B: Q1.2, U1.30
/Powertrain/SH_C: Q2.2, U1.27
/Powertrain/SL_A: NT6.2, Q3.6, R11.1, U1.34
/Powertrain/SL_B: NT4.2, Q1.6, R8.1, U1.31
/Powertrain/SL_C: NT5.2, Q2.6, R9.1, U1.26
/Powertrain/SN1: C9.1, NT6.1, U1.23
/Powertrain/SN2: C16.1, NT4.1, U1.21
/Powertrain/SN3: C18.1, NT5.1, U1.19
/Powertrain/SP1: C9.2, NT3.1, U1.24
/Powertrain/SP2: C16.2, NT1.1, U1.22
/Powertrain/SP3: C18.2, NT2.1, U1.20
/Powertrain/SPI_CLK: U1.12, U3.12, U5.24
/Powertrain/SPI_CS_0: U1.9, U5.25
/Powertrain/SPI_MISO: U1.11, U3.15, U5.26
/Powertrain/SPI_MOSI: U1.10, U3.14, U5.27
/RXCAN: U3.20, U8.4
/TCK: J5.4, U5.23
/TDI: J5.8, U5.20
/TDO: J5.6, R25.2, R28.1, U5.22
/TI_MCU/ADCINA0: C17.1, R15.2, R16.1, U5.10
/TI_MCU/ADCINA1: C7.1, R4.2, R13.1, U5.8
/TI_MCU/ADCINA3: C6.1, R3.2, R12.1, U5.7
/TI_MCU/ADCINA7: C8.1, R5.2, R14.1, U5.6
/TI_MCU/ADCINB1: C24.1, R20.2, U5.13
/TI_MCU/ADCINB3: C25.1, R21.2, U5.15
/TI_MCU/ADCINB7: C26.1, R22.2, U5.18
/TI_MCU/CAN_INT: R17.2, U3.11, U5.47
/TI_MCU/EPWM1A: U1.2, U5.29
/TI_MCU/EPWM1B: U1.3, U5.28
/TI_MCU/EPWM2A: U1.4, U5.37
/TI_MCU/EPWM2B: U1.5, U5.38
/TI_MCU/EPWM3A: U1.6, U5.39
/TI_MCU/EPWM3B: U1.7, U5.40
/TI_MCU/GPIO7: U1.47, U5.42
/TI_MCU/GPIO33: R31.2, U5.36
/TI_MCU/GPIO34: R26.2, R29.1, U5.19
/TI_MCU/SPI_CS_1: U3.16, U5.31
/TMS: J5.2, U5.21
/TRST: J5.10, R27.1, U5.2
/TXCAN: U3.19, U8.1
GND: C1.2, C3.2, C5.2, C6.2, C7.2, C8.2, C10.2, C12.2, C13.2, C14.2, C15.2, C17.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C49.2, C50.2, J5.7, J5.9, J8.1, NT1.2, NT2.2, NT3.2, R7.2, R8.2, R9.2, R11.2, R12.2, R13.2, R14.2, R16.2, R19.2, R24.2, R27.2, R28.2, R29.2, U1.14, U1.45, U1.49, U2.3, U2.9, U3.8, U3.21, U4.1, U4.4, U4.5, U5.12, U5.30, U5.33, U5.34, U5.44, U8.2, U8.8, U8.9, Y1.2, Y1.4
unnamed: C2.1, U1.42
unnamed: C2.2, U1.43
unnamed: C3.1, U1.15
unnamed: C4.1, U1.40
unnamed: C4.2, U1.39
unnamed: C5.1, U1.46
unnamed: C19.2, U1.38
unnamed: C20.1, U1.37
unnamed: C21.1, U3.6, Y1.3
unnamed: C22.1, U3.7, Y1.1
unnamed: C34.1, U5.43
unnamed: C36.1, L2.2, U5.11
unnamed: C37.1, L3.2, U5.35
unnamed: C38.1, U5.32
unnamed: D1.1, R7.1
unnamed: D2.1, R10.1
unnamed: D3.1, R19.1
unnamed: D4.1, R24.1
unnamed: D5.1, R31.1
unnamed: L1.1, U4.7
unnamed: R2.2, U1.44
unnamed: R18.2, U3.17
unnamed: R23.2, U4.8

File PCBs/Thruster_Controller/Thruster_Controller_bom_001.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet,Digikey,Voltage
1,"Unpolarized capacitor, small symbol",C_Small,C2 C4,0.047uF,C_0402,2,,490-10702-1-ND,
2,"Unpolarized capacitor, small symbol",C_Small,C6 C7 C8 C17 C23 C30 C42,0.1uF,C_0402,7,,490-10698-1-ND,
3,"Unpolarized capacitor, small symbol",C_Small,C9 C16 C18,1000pF,C_0402,3,,311-1036-1-ND,
4,"Unpolarized capacitor, small symbol",C_Small,C49,10uF,C_0805,1,,1276-6454-1-ND,25V
5,"Unpolarized capacitor, small symbol",C_Small,C21 C22,15pF,C_0402,2,~,732-7456-1-ND,
6,"Unpolarized capacitor, small symbol",C_Small,C3 C5 C20 C27 C28 C29 C39 C40 C41,1uF,C_0603,9,,1276-1102-1-ND,25V
7,"Unpolarized capacitor, small symbol",C_Small,C19,2.2uF,C_0603,1,,490-10731-1-ND,
8,"Unpolarized capacitor, small symbol",C_Small,C34 C35 C36 C37 C38,2.2uF,C_0402,5,~,490-10451-1-ND,
9,"Unpolarized capacitor, small symbol",C_Small,C24 C25 C26,2200pF,C_0402,3,,490-6359-1-ND,
10,Unpolarized capacitor,C,C10 C13 C15,22uF,CP_Elec_6.3x5.8,3,~,565-APXJ160ARA221MF61GCT-ND,
11,Unpolarized capacitor,C,C12 C14 C31,22uF,C_1206,3,~,1276-1101-1-ND,
12,"Unpolarized capacitor, small symbol",C_Small,C50,22uF,C_0805,1,,1276-1100-1-ND,
13,"Unpolarized capacitor, small symbol",C_Small,C1,4.7uF,C_0603,1,,1276-1900-1-ND,
14,"Light emitting diode, filled shape",LED_ALT,D1,BLUE,LED_0603,1,~,732-4966-1-ND,
15,"Light emitting diode, filled shape",LED_ALT,D3,GREEN,LED_0603,1,~,732-4980-1-ND,
16,"Light emitting diode, filled shape",LED_ALT,D5,Orange,LED_0603,1,~,160-1180-1-ND,
17,"Light emitting diode, filled shape",LED_ALT,D2 D4,RED,LED_0603,2,~,732-4978-1-ND,
18,"Generic connector, single row, 01x01, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x01,J4 J6,Conn_01x01,CAN_Pad,2,~,,
19,"Generic connector, single row, 01x01, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x01,J7 J8,Conn_01x01,Bus_Pad,2,~,,
20,"Generic connector, single row, 01x01, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x01,J1 J2 J3,PHASE_A,Phase_Pad,3,~,,
21,"Generic connector, double row, 02x05, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_02x05_Odd_Even,J5,Pogo Conn,Tag-Connect_TC2050-IDC-NL,1,~,,
22,"Inductor, small symbol",L_Small,L1,2.2uH,L_0805,1,~,587-3018-1-ND,
23,"Inductor, small symbol",L_Small,L2,FB,L_0805,1,~,240-2549-1-ND,
24,"Inductor, small symbol",L_Small,L3,FB,L_0402,1,~,445-172882-1-ND,
25,"Net tie, 2 pins",Net-Tie_2,NT1 NT2 NT3 NT4 NT5 NT6,Net-Tie_2,NetTie-2_SMD_5mil,6,~,,
26,,SIZF906DT,Q1 Q2 Q3,SIZF906DT,SIZF906DT,3,http://www.vishay.com/docs/67547/sizf906dt.pdf,SIZF906DT-T1-GE3CT-ND,
27,"Resistor, US symbol",R_US,R2,100,R_0603,1,~,RHM100DCT-ND,
28,"Resistor, small US symbol",R_Small_US,R23,100k,R_0402_NoSilk,1,~,RMCF0402JT100KCT-ND,
29,"Resistor, US symbol",R_US,R1 R6,10k,R_0603,2,~,RMCF0603JT10K0CT-ND,
30,"Resistor, small US symbol",R_Small_US,R17 R18,10k,R_0402,2,~,311-10KJRCT-ND,
31,"Resistor, small US symbol",R_Small_US,R35,120,R_0402,1,~,311-120JRCT-ND,
32,"Resistor, small US symbol",R_Small_US,R27 R28 R29 R30,2.2k,R_0402,4,~,311-2.2KJRCT-ND,
33,"Resistor, US symbol",R_US,R7,2.7k,R_0603,1,~,RMCF0603JT2K70CT-ND,
34,"Resistor, US symbol",R_US,R3 R4 R5 R15,22.0k,R_0402,4,~,RMCF0402FT22K0CT-ND,
35,"Resistor, US symbol",R_US,R10 R19,330,R_0805,2,~,2019-RK73B2ATTD331JCT-ND,
36,"Resistor, US symbol",R_US,R12 R13 R14 R16,4.99k,R_0402,4,~,311-4.99KLRCT-ND,
37,"Resistor, US symbol",R_US,R20 R21 R22,56,R_0402,3,~,311-56JRCT-ND,
38,"Resistor, US symbol",R_US,R8 R9 R11,5m,R_2512,3,,YAG6105CT-ND,
39,"Resistor, US symbol",R_US,R24 R31,680,R_0603,2,~,RMCF0603JT680RCT-ND,
40,"Resistor, small US symbol",R_Small_US,R25 R26,820,R_0402,2,~,311-820JRCT-ND,
41,,DRV8305,U1,DRV8305,DRV8305,1,http://www.ti.com/lit/ds/symlink/drv8305.pdf,296-42659-1-ND,
42,,MCP2515-QFN20-MCU_Powertrain,U3,MCP2515,QFN-20-1EP_4x4mm_Pitch0.5mm,1,http://ww1.microchip.com/downloads/en/DeviceDoc/21801e.pdf,MCP2515T-I/MLCT-ND,
43,"High-Speed CAN Transceiver, 1Mbps, 5V supply, Vio pin, -40C to +125C, DFN8 package",MCP2562-E-MF,U8,MCP2562,DFN-8-1EP_3x3mm_Pitch0.65mm,1,http://ww1.microchip.com/downloads/en/DeviceDoc/25167A.pdf,MCP2562-E/MF-ND,
44,,RTQ2569-50GQW-MCU_Powertrain,U2,RTQ2569-50GQW,DFN-8-1EP_3x3mm_Pitch0.65mm,1,,1028-1523-1-ND,
45,,TMS320F28027F-MCU_Powertrain,U5,TMS320F28027F,LQFP-48_7x7mm_Pitch0.5mm,1,,296-36409-ND,
46,,TPS62172DSGR,U4,TPS62172DSGR,8-Pin_WSON,1,http://www.ti.com/lit/ds/symlink/tps62171.pdf,296-39449-1-ND,
47,"Four pin crystal, GND on pins 2 and 4",Crystal_GND24,Y1,20MHz,Crystal_SMD_SeikoEpson_TSX3225-4pin_3.2x2.5mm,1,~,SER4249CT-ND,

Component Groups:,47
Component Count:,105
Fitted Components:,105
Number of PCBs:,1
Total components:,105
Schematic Version:,001
Schematic Date:,2020-01-15
PCB Variant:,[u'default']
BoM Date:,2020-04-05 2:57:29 AM
Schematic Source:,D:\Motor Controller Research\GitHub\motor-controller\PCBs\Thruster_Controller\Thruster_Controller.sch
KiCad Version:,Eeschema (5.1.5)-3

## KiCad design PCBs/RPM Sensor/RPM Sensor.kicad_pcb

Parts:
C1, C2: 100uF; CP_Tantalum_Case-U_EIA-6032-15_Reflow; Digikey 478-7995-1-ND
C3: 0.1uF; C_0805; Digikey 311-1361-1-ND
C4: 10uF; C_0805; Digikey 399-4925-1-ND
H1, H2: MountingHole; MountingHole_3.2mm_M3_ISO14580
J1, J3, J12, J13, J14, J15, J16: I; TestPoint_Pad_D2.0mm
J2: B; TestPoint_Pad_D2.0mm
J4: A; TestPoint_Pad_D2.0mm
J5: U; TestPoint_Pad_D2.0mm
J6: V; TestPoint_Pad_D2.0mm
J7: W/PWM; TestPoint_Pad_D2.0mm
J8: SCL/CLK; TestPoint_Pad_D2.0mm
J9: NSL/DI; TestPoint_Pad_D2.0mm
J10: DO/DO; TestPoint_Pad_D2.0mm
J11: SEL/SEL; TestPoint_Pad_D2.0mm
U1: MAG_ENCODER_AEAT-8800-Q24; QFN-24-1EP_4x4mm_Pitch0.5mm; Digikey 516-3787-ND

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, J3.1, U1.14 (VDDA), U1.19 (VDDA)
GND: C1.2, C2.2, C3.2, C4.2, J12.1, J13.1, J14.1, J15.1, J16.1, U1.13 (VSS), U1.20 (VSS), U1.25 (PAD)
unnamed: J1.1, U1.7 (I)
unnamed: J2.1, U1.8 (B)
unnamed: J4.1, U1.9 (A)
unnamed: J5.1, U1.22 (U)
unnamed: J6.1, U1.23 (V)
unnamed: J7.1, U1.24 (W/PWM)
unnamed: J8.1, U1.10 (SSI_SCL_SPI_CLK)
unnamed: J9.1, U1.11 (SSI_NSL_SPI_DI)
unnamed: J10.1, U1.12 (SSI_DO_SPI_DO)
unnamed: J11.1, U1.21 (SSI_SPI_SEL)

Notes on the sheet:
place next to pins 14/13
place next to pins 19/20

Board: 2 copper layers, 39.4 x 40.0 mm, 23 parts (0 on the bottom side), 12 nets.

## KiCad design PCBs/XDS100v2 Programmer/XDS100v2 Programmer.kicad_pcb

Schematic: XDS100v2 Programmer.sch, XDS100v2 Programmer for TI MCUs

Parts:
C1, C2: 4.7uF; C_0805; Digikey 490-14466-1-ND
C3: 1uF; C_0805; Digikey 399-8011-1-ND
C4: 100uF; CP_Tantalum_Case-U_EIA-6032-15_Reflow; Digikey 478-7995-1-ND
C5, C6, C7, C8, C10, C11: 0.1uF; C_0805; Digikey 311-1361-1-ND
C9: 3.3uF; C_0805; Digikey 490-13309-1-ND
C12, C13: 36p; C_0603; Digikey 490-1416-1-ND
D1: LED; LED_0805; Digikey 475-1278-1-ND
D2, D3: LED; LED_0805; Digikey 160-1579-1-ND‎
F1: 500mA; 1812_PloyFuse; Digikey MF-MSMF050-2CT-ND
H1, H2, H3, H4, H5, H6: MountingHole_Pad; MountingHole_3mm_Pad_Via
J1: USB_B_Mini; USB_Mini_B_32005-201; Digikey ED2992CT-ND
L1, L2: FB; L_0402; Digikey 553-2374-1-ND‎
R1: 820; R_0805; Digikey 311-820ARCT-ND
R2, R7: 10k; R_0805; Digikey 311-10.0KCRCT-ND
R3, R4: 1k; R_0805; Digikey 311-1.0KARCT-ND
R5, R10: 2.2k; R_0805; Digikey 311-2.20KCRCT-ND
R6: 12k; R_0805; Digikey A129762CT-ND
R8, R9: 330; R_0805; Digikey A129743CT-ND
SW1, SW2: SW_DIP_x02; CTS_DPST_Switch; Digikey CT204211ST-ND
SW3: SW_DIP_x03; CTS_3DIP_Switch; Digikey CT2043ST-ND
U1: TLV1117-33; SOT-223; Digikey 296-50648-ND
U2: ISO7240; SOIC-16W_7.5x10.3mm_Pitch1.27mm; Digikey 296-22617-1-ND
U3: EEPROM_Array; SOT-23-6
U4: FT2232H; QFN-64-1EP_9x9mm_Pitch0.5mm; Digikey 768-1025-1-ND
U5: ISO7231; SOIC-16W_7.5x10.3mm_Pitch1.27mm; Digikey 296-22960-5-ND
U6: EEPROM_Array_8pin; EEPROM_8pin; Digikey 1662-2080-1-ND‎
Y1: 12MHz; Crystal_SMD_HC49-SD; Digikey XC2079CT-ND

Connections:
+1V8: C6.1, C7.1, C8.1, C9.1, U4.12, U4.37, U4.49, U4.64
+3V3: C4.1, C5.1, C10.2, C11.2, D2.2 (A), D3.2 (A), L1.1, L2.1, R1.1, R2.1, R3.1, R7.1, SW1.1, U1.2 (VO), U2.1, U3.6, U4.20, U4.31, U4.42, U4.50, U4.56, U5.10, U5.16, U6.8
+5V: C3.1, F1.1, U1.3 (VI)
/3V3_MCU: SW1.4, U2.10, U2.16, U5.1, U5.7; also elsewhere on the board
/D+: J1.3 (D+), U4.8
/D-: J1.2 (D-), U4.7
/FTDI_CLK: U3.4, U4.62, U6.2
/FTDI_CS: U3.5, U4.63, U6.1
/FTDI_DATA: R5.2, R10.2, U3.3, U4.61, U6.3
/GPIO28: SW2.4; also elsewhere on the board
/GPIO29: SW2.3; also elsewhere on the board
/JTAG_TRST: SW3.4, U5.5
/SCI_RX: SW2.1, U2.11
/SCI_TX: SW2.2, U5.4
/TCK: U2.14; also elsewhere on the board
/TDI: U2.13; also elsewhere on the board
/TDO: U5.3; also elsewhere on the board
/TMS: U2.12; also elsewhere on the board
/TRST: SW3.3; also elsewhere on the board
GND: SW1.3, U2.9, U2.15, U5.2, U5.8; also elsewhere on the board
GNDD: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.1, C12.2, C13.2, D1.1 (K), J1.5 (GND), J1.6 (Shield), R4.2, R6.1, SW1.2, U1.1 (GND), U2.2, U2.8, U3.2, U4.1, U4.5, U4.10, U4.11, U4.13, U4.15, U4.25, U4.35, U4.47, U4.51, U4.65, U5.9, U5.15, U6.5, U6.6
unnamed: C1.1, L2.2, U4.4
unnamed: C2.1, L1.2, U4.9
unnamed: C12.1, U4.2, Y1.1
unnamed: C13.1, U4.3, Y1.2
unnamed: D1.2 (A), R1.2
unnamed: D2.1 (K), R8.1
unnamed: D3.1 (K), R9.1
unnamed: F1.2, J1.1 (VBUS)
unnamed: R2.2, R5.1, U3.1, U6.4
unnamed: R3.2, U4.14
unnamed: R4.1, U4.32
unnamed: R6.2, U4.6
unnamed: R8.2, U4.54
unnamed: R9.2, U4.55
unnamed: R7.2, R10.1
unnamed: U2.3, U4.16
unnamed: U2.4, U4.17
unnamed: U2.5, U4.19
unnamed: U2.6, U4.38
unnamed: U4.18, U5.14
unnamed: U4.21, U5.12
unnamed: U4.39, U5.13
unnamed: U4.40, U4.41

Notes on the sheet:
Duplicate incase 8pin EEPROM does not work
PWR_ISO
XDS100 Serial
Boot Mode
Programming Cable Interface
Follows ARM 10 Pin JTAG Interface, slightly modified
